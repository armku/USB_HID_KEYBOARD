# IAR project USB_Keyboard.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xx8 ST STM32F10xx8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: ..\User; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Libraries\CMSIS\Core\CM3; ..\Libraries\USBLib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USB_Keyboard.srec
  ILINK.IlinkOutputFile: USB_Keyboard.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CM3
    ../Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
    ../Libraries/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_md.s
  group LIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
  group USBLib
    ../Libraries/USBLib/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group USER
    ../User/: hw_config.c Keyboard.c main.c stm32f10x_it.c usb_desc.c usb_istr.c usb_prop.c usb_pwr.c
